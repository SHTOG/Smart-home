# Keil uVision project Curtain.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x2800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_LD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\StepMotor;..\HARDWARE\Zigbee;..\HARDWARE\IWDG;..\HARDWARE\TEA;..\HARDWARE\TIMER;..\HARDWARE\KEY;..\HARDWARE\24Cxx;..\HARDWARE\IIC
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/Zigbee/: Zigbee.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/TEA/: tea.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/StepMotor/: stmt.c
    ../HARDWARE/24Cxx/: 24Cxx.c
    ../HARDWARE/IIC/: IIC.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_ld.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_tim.c
  group README
    ../: README.TXT
